# Keil uVision project dual_vol.uvprojx, settings and files
target dual_vol (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: dual_vol +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/Include/dsp;../Drivers/CMSIS/DSP/PrivateInclude;../BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: ad7616.c Control.c fft.c global.c LSC_Airthmeitc.c ProRecData_1.c RingBuffer.c main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CMSIS/DSP
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../Drivers/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../Drivers/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../Drivers/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
  group Application/BSP
    ../BSP/: driver.c
    ../BSP/SERIAL/: serial.c
    ../BSP/RINGQUEUE/: ringqueue.c
  group Application/COMM
    ../Communication/: Notify.c protocol.c SendMessage.c
  group Application/USER
    ../USER/: user.c
  group Application/Task
    ../Task/: sys_task.c sys_time.c
software components: CMSIS:CORE 4.3.0
